FILESEXTRAPATHS:prepend := "${THISDIR}/linux-reiq:"
SRC_URI += "file://imx8mp-reiq-som.dts"
KERNEL_DEVICETREE += "freescale/imx8mp-reiq-som.dtb"
